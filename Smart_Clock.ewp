# IAR project Smart_Clock.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK40DX256xxx10 Freescale MK40DX256xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCIncludePath2: Source\OS\inc; Source\Include; $TOOLKIT_DIR$\CMSIS\Include; Source\Startup
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Smart_Clock.hex
  ILINK.IlinkOutputFile: Smart_Clock.out
  ILINK.IlinkIcfFile: Smart_Clock.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Source/Include
    Source/Include/: Clock.h DisplayM.h Driver_SLCD.h ds18b20.h Fonts_LCD.h MK40X256VMD100.h PounceTypes_v2.h SM.h TD.h
  group Source/OS/inc
    Source/OS/inc/: List.h OS.h OS_Cfg.h OS_types.h Port.h Task.h
  group Source/OS/src
    Source/OS/src/: List.c OS.c Port.c port_asm.s Task.c
  group Source/Sources
    Source/Sources/: Clock.c DisplayM.c Driver_SLCD.c ds18b20.c Fonts_LCD.c main.c SM.c TD.c
  group Source/Startup
    Source/Startup/: vector_table_M_for_MK40X256.s
